# Keil uVision project Lab11.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..\SW
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./inc/: startup.s ST7735.c
    ./: main.c Blynk.c esp8266.c Timer2.c Timer2.h Timer3.c Timer3.h
    ../inc/: LED.c LED.h Timer1A.c Timer1A.h PLL.c PLL.h PortF.c PortF.h UART.c Timer5A.c Timer5A.h
    ../Lab3/: buttons.c
